# Keil uVision project BLE.uvprojx, settings and files
target CH57x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: BLE +hex
  c flags: uC99=1 v6Lang=1 v6LangP=1
  c define: DEBUG
  c include: ..\APP\include;..\Profile\include;..\..\HAL\include;..\..\LIB;..\..\..\SRC\CMSIS\Include;..\..\..\SRC\StdPeriphDriver\inc;..\..\..\USB\Host\USB_LIB
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group app
    ../APP/: hidkbd.c hidkbd_main.c usbhid.c power.c mykeyboard.c ws2812.c app_adc.c
  group profile
    ../Profile/: battservice.c devinfoservice.c hiddev.c hidkbdservice.c scanparamservice.c
  group drive
    ../../../SRC/Startup/: startup_ARMCM0.s
    ../../../SRC/StdPeriphDriver/: CH57x_clk.c CH57x_gpio.c CH57x_pwr.c CH57x_sys.c CH57x_uart1.c CH57x_int.c CH57x_usbdev.c CH57x_adc.c CH57x_flash.c CH57x_lcd.c CH57x_pwm.c CH57x_spi0.c CH57x_timer0.c CH57x_spi1.c
  group hal
    ../../HAL/: MCU.c RTC.c SLEEP.c
  group lib
    ../../LIB/: CH57xBLE.LIB CH57xBLE_LIB.H
  group config
    ../../HAL/include/: config.h
